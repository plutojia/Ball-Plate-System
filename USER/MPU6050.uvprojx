# Keil uVision project MPU6050.uvprojx, settings and files
target MPU6050 (ARM-ADS)
  device: STM32F407VE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MPU6050 +hex
  c flags: Optim=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\LCD;..\HARDWARE\IIC;..\HARDWARE\MPU6050;..\HARDWARE\MPU6050\eMPL;..\FWLIB\inc;..\HARDWARE\KEY;..\USMART;..\CONTROL;..\HARDWARE\TIMER;..\HARDWARE\RNG;..\HARDWARE\MOTOR;..\CONTROL\DataScope_DP;..\CONTROL\show;..\CONTROL\control;..\CONTROL\PID;..\CONTROL\helpers;..\HARDWARE\ULTRASONIC;..\HARDWARE\US-016;..\HARDWARE\12864;..\HARDWARE\INFRARED;..\HARDWARE\ENCODER;..\HARDWARE\SSI;..\HARDWARE\NRF24L01;..\HARDWARE\SPI;..\HARDWARE\USART3
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c stm32f4xx_conf.h
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/RNG/: rng.c
    ../HARDWARE/MOTOR/: motor.c
    ../HARDWARE/12864/: 12864.c
    ../HARDWARE/ENCODER/: encoder.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/NRF24L01/: 24l01.c
    ../HARDWARE/USART3/: USART3.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_rng.c stm32f4xx_adc.c stm32f4xx_spi.c
  group README
    ../: readme.txt
  group CONTROL
    ../CONTROL/DataScope_DP/: DataScope_DP.C
    ../CONTROL/show/: show.c
    ../CONTROL/PID/: PID.c
    ../CONTROL/control/: control.c
    ../CONTROL/helpers/: helpers.c
